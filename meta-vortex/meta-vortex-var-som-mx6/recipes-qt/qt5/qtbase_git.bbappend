PACKAGECONFIG_append = " gif"

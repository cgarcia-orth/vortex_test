FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://vortex_maestro_dt_changes.diff"


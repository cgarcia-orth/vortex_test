SRC_URI = "git://source.codeaurora.org/external/imx/imx-alsa-plugins.git;protocol=git;branch=${SRCBRANCH}"


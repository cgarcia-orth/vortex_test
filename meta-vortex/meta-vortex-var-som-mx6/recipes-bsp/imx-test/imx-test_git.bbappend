SRC_URI = " \
    git://source.codeaurora.org/external/imx/imx-test.git;protocol=git;branch=${SRCBRANCH} \
    file://0001-test-Makefile-Add-include-path-to-CC-command.patch \
    file://memtool_profile \
"


SRC_URI = "git://source.codeaurora.org/external/imx/imx-lib.git;protocol=git;branch=${SRCBRANCH}"

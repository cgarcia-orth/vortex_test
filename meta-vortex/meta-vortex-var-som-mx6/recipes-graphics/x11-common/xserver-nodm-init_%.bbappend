PACKAGECONFIG += "nocursor"
PACKAGECONFIG += "blank"

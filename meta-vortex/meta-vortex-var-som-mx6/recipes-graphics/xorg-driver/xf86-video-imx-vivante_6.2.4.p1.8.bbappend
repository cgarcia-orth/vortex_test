SRC_URI = "git://source.codeaurora.org/external/imx/xf86-video-imx-vivante.git;protocol=git;branch=${SRCBRANCH} \
           file://rc.autohdmi"


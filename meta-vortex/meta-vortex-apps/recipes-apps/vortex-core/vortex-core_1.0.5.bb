require vortex-core-common.inc

DEPENDS += "systemd"




inherit nativesdk
require vortex-core-common.inc

export CMAKE_VORTEX_CORE_NATIVESDK="true"
